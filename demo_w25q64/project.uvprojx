# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;applications;rt-thread\components\libc\compilers\common\include;libraries\HAL_Drivers\drivers\drv_flash;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\libc\posix\io\eventfd;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;rt-thread\components\libc\posix\io\epoll;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\spi;libraries\HAL_Drivers\drivers\config;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;rt-thread\include;board\ports;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;.;rt-thread\libcpu\arm\common;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;rt-thread\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: dev_init.c app_u.c bootloader.c spi_w25q64.c app_data.c main.c bsp_flash.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_f1.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_flash.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
